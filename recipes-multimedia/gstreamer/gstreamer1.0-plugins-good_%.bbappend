PACKAGECONFIG:append:k3 = " vpx"
