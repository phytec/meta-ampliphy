SRC_URI:remove = "file://0001-Add-stdout-mode-to-allow-streaming-over-the-network-.patch"
SRCREV = "65f740aa1758531fd810339bc1b7d1d33666e28a"
