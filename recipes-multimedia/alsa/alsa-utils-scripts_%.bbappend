PACKAGECONFIG = "udev bat"
