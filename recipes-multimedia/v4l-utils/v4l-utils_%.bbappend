FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "\
  file://numeric-codes.patch \
"
