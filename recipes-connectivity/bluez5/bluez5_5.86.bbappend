FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-adapter-Fix-Failed-to-set-default-system-config-sta.patch"
