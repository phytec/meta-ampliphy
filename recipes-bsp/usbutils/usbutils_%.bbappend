FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "\
            file://0001-usb-devices-Fix-usb-devices-with-busybox.patch \
           "
