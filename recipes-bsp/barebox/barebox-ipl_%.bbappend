BAREBOX_LOCALVERSION = "-${DISTRO_VERSION}"
