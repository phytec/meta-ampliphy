ALLOW_EMPTY:${PN}-mkspecs = "1"
ALLOW_EMPTY:${PN}-staticdev = "1"
