FILES_${PN}-qmlplugins += "${OE_QMAKE_PATH_QML}/*/*/*/*.ttf"
