ALLOW_EMPTY:${PN}-plugins = "1"
