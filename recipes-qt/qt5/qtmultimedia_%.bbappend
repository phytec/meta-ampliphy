PACKAGECONFIG:append = " gstreamer"
