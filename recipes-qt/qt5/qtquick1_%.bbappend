ALLOW_EMPTY_qtquick1-mkspecs = "1"
ALLOW_EMPTY_qtquick1-plugins = "1"
ALLOW_EMPTY_qtquick1-qmlplugins = "1"
