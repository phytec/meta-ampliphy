FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI_append_mx6ul = " file://0001-main.qml-remove-imx6ul-non-working-demos.patch"

