LIC_FILES_CHKSUM = "file://main.cpp;md5=a3ecdc1d777da347f1bf35dd9966606f"

SRCREV = "6178748a6ea34df40a8e3c9ce67137e33383bb0e"

#hotfix dependcies correction of qt5everywheredemo
DEPENDS += "qtmultimedia qtsvg"
