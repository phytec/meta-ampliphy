FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Add-Node-7.x-aka-V8-5.2-support.patch \
"
