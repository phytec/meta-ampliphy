PACKAGECONFIG = "zlib openssl"
EXTRA_OECONF_append = " ${PACKAGECONFIG_CONFARGS}"
