inherit pypi setuptools3
require python-smbus2.inc
