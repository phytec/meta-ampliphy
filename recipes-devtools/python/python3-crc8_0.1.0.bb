inherit setuptools3
require python-crc8.inc
