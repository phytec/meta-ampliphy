PACKAGES =+ "${PN}-donotwork"
FILES:${PN}-donotwork = "${sbindir}/eeprog ${sbindir}/eeprom ${sbindir}/eepromer"
