# Needed, as long as we do not use kernel >=4.15.
RDEPENDS_packagegroup-base-wifi_remove = "wireless-regdb-static"
RDEPENDS_packagegroup-base-wifi_append = " wireless-regdb"
