RDEPENDS:${PN} += "nativesdk-gettext"
