# Copyright (C) 2020 Maik Otto <m.otto@phytec.de>
# Released under the MIT license (see COPYING.MIT for the terms)

require phytec-dev-ca.inc

SRC_URI[tarball.md5sum] = "3adfb4409f9557239f635ed35344583f"
SRC_URI[tarball.sha256sum] = "c96bd98d9bc6a579ee8112d95a3390fd60070738e03bec1ff43bd728f2ec3d5b"

