FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI_remove = "file://0001-mod_cgi-buffers-data-without-bound.patch"
