SYSTEMD_AUTO_ENABLE:am62xx = "enable"
SYSTEMD_AUTO_ENABLE:am62axx = "enable"
