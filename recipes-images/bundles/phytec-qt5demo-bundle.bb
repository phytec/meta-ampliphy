require phytec-base-bundle.inc
RAUC_SLOT_rootfs ?= "phytec-qt5demo-image"
