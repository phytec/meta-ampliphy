require phytec-base-bundle.inc
RAUC_SLOT_rootfs ?= "phytec-headless-image"
