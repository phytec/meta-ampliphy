FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"

SRC_URI += "file://0001-highgui-fix-build-with-Q6-6.9-and-highgui-module-ena.patch"
