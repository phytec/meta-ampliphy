# Required by qtbase
PACKAGECONFIG_append = " pcre16"
