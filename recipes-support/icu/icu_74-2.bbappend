FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://ICU-22813_rise_buffer_sizes_pkgdata_PR3058.patch"
