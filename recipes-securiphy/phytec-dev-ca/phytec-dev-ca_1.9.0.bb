require phytec-dev-ca.inc

SRC_URI[sha256sum] = "c811e04f1eb9a823fea2d7bfd4d7256cc21d74e5cd50d1c47dec8841d42adbb9"
