require phytec-dev-ca.inc

SRC_URI[sha256sum] = "f133cac9e879e56dc6a3c14eff5252b53d4df90411c3a0bfc11088ce9f22e9fe"
