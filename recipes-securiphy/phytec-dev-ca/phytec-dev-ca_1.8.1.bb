require phytec-dev-ca.inc

SRC_URI[sha256sum] = "cb2f7856cdb4aed24225283e7795fe40401ee72d9866f0e6a47552d4eea0f08c"
