require phytec-dev-ca.inc

SRC_URI[sha256sum] = "ee5573fa32b93059e0b3479ebd383d567f47a8a7e057472da5090b4c13772ec0"
