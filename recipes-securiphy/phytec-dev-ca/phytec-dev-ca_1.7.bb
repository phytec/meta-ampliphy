require phytec-dev-ca.inc

SRC_URI[sha256sum] = "9e73b1b40e2d88f7fc92abfc19bdded86d0f5474214891c73f82047d393f7ff3"
