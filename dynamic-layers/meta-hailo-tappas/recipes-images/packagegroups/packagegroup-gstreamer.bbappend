RDEPENDS:${PN}:append:mx8mp-generic-bsp = " \
    libgsthailotools \
"
