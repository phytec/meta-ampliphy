RDEPENDS:${PN}:append:am57xx = " omapconf"
