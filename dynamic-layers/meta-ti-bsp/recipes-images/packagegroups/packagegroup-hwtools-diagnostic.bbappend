RDEPENDS:${PN}:append:k3 = " k3conf"
