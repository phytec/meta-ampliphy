RDEPENDS:${PN}:append:k3 = " \
    cc33xx-fw \
    cc33calibrator \
    cc33conf \
    cc33xx-target-scripts \
"
