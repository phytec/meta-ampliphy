RDEPENDS:${PN}:append:k3 = " \
    ti-rpmsg-char \
"
