PACKAGECONFIG:append = " hostnamed"
