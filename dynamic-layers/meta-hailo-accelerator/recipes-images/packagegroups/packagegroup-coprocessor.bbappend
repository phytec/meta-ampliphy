RDEPENDS:${PN}:append:mx8mp-generic-bsp = " \
    hailo-pci \
    hailo-firmware \
"
