RDEPENDS:${PN}:remove = "tpm2-abrmd"
