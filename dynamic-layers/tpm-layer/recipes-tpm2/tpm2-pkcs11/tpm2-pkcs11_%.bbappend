EXTRA_OECONF += "--with-storedir=/mnt/config/tpm2/pkcs11"
