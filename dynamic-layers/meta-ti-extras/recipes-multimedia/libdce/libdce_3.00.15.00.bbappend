# Workaround to resolve clone issues with opmapzoom.org
# This archive is from our nightly builds and should be
# moved to a TI Git server.
SRC_URI = "git://github.com/phytec-mirrors/libdce;protocol=https;branch=master"
