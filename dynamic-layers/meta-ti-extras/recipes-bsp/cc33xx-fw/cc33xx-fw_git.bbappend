# Use newer version of cc33xx firmware
SRCREV = "0b4f850d6c0fd8e0fe0ae1d3e80ac6733aced29b"
PV = "1.7.0.323"
