RDEPENDS:${PN}:append:mx8mp-generic-bsp = " \
    libhailort \
    hailortcli \
    pyhailort \
"
