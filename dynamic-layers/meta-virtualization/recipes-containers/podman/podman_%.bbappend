do_install:append () {
    rm -rf ${D}/${bindir}/podman-remote
}
