PROVIDES += "virtual/runc"
RPROVIDES:${PN} = "virtual-runc"
