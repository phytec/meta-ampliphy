RDEPENDS:${PN} += "${PYTHON_PN}-dotenv"
