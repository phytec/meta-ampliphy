RDEPENDS:${PN}:append:mx93-nxp-bsp = " \
    ethos-u-firmware \
    ethos-u-driver-stack \
    ethos-u-vela \
    tensorflow-lite-ethosu-delegate \
"
