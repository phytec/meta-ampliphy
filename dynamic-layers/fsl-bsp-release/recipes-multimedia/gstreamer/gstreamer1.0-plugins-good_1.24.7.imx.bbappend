FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-v4l2object-Remove-little-endian-marker-on-8-bit-baye.patch"

