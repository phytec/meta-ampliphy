FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-v4l2src-Fix-8-bit-bayer-formats.patch"

