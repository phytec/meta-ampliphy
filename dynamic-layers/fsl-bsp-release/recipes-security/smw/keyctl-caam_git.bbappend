EXTRA_OEMAKE = "KEYBLOB_LOCATION=/mnt/config/secrets/"
