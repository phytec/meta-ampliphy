EXTRA_OEMAKE_append = " CFG_TEE_FS_PARENT_PATH=/mnt/config/optee "
