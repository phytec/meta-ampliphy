RDEPENDS:${PN}:append:mx8mp-nxp-bsp = " \
    tensorflow-lite-vx-delegate \
"
