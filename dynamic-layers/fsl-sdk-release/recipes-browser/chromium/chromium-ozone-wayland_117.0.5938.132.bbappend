DEPENDS:remove = "gn-native"
DEPENDS += "gn-chromium-native"
