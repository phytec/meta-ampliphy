EXTRA_OECMAKE:append:update = " -DCFG_TEE_FS_PARENT_PATH='/mnt/config/optee' "
