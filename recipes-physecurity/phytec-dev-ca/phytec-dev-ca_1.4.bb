require phytec-dev-ca.inc

SRC_URI[tarball.md5sum] = "bfd3274145b6e6f96fa33354c31ee571"
SRC_URI[tarball.sha256sum] = "48bbb1a7ae56e58312b91374db6b0c0fd7955d105246bfbdaa80810afc370087"
