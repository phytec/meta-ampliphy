require phytec-dev-ca.inc

SRC_URI[sha256sum] = "8d2e0bf21b25014ae2020289433fcd9cd03f58bf66f81b7a51c74928ca429910"
