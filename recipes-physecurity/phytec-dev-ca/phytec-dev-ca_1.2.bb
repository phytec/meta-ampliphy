require phytec-dev-ca.inc

SRC_URI[tarball.md5sum] = "681c5685b4c248c7d9b8e01de8cb2d4d"
SRC_URI[tarball.sha256sum] = "11accb040c48b2529d953add6fd505938f8bd09852dc7e77d0ecfd641a258bd0"
