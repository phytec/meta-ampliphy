require phytec-dev-ca.inc

SRC_URI[tarball.md5sum] = "c2378f25bbda2949f5bc278dcfef98b2"
SRC_URI[tarball.sha256sum] = "f2fc15d438dd363f855cd621e019074ab7fdd50a7aa67bbae2a0360e4995e878"
