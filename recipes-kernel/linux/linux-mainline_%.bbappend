LINUX_VERSION_EXTENSION = "-${DISTRO_VERSION}"
