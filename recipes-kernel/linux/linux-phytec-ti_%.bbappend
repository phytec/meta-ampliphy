require recipes-kernel/linux/linux-common-append.inc
