require recipes-kernel/linux/linux-common-append.inc

LINUX_VERSION_EXTENSION = "-${DISTRO_VERSION}"
