# Remove after patch is applied in meta-openembedded
# https://lists.openembedded.org/g/openembedded-devel/message/95646
SRC_URI = "git://github.com/google/googletest.git;branch=main;protocol=https"
